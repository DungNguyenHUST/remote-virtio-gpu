EXTRA_OECONF += "--with-pgm"

DEPENDS += "libpgm"
