require core-image-rvgpu-weston.inc
